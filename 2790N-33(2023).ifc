Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-14T17:10:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 14 17:10:13 2023 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\759ee022-3bab-4bb7-b5d6-2821236c801b\dcba7086-1fa6-4d05-8082-e992d64675b1\ifc * Database version: 5507 * Database creation date: Wed Jun 14 17:10:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 14 17:10:12 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 14 17:10:12 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowController: 2790N-33 Shower set, 2790N-33(2023):2790N-33 Shower set:300768
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 124 mm; NominalHeight: 765.2 mm; NominalWidth: 236.5 mm
Type - General - Author: BIMStone; BIMObjectName: 2790N-33(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150099700; EN Standard: EN1112; ETIM Class Number: EC010109 Sliding rod combination; Noise Class 02ls: I (ISO 3822); Sales Package dimensions (LxWxH): 779 x 156 x 74; UNSPSC Class Number: 30181503 Showers; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/2790N-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2790N-33; 3D View: https://static.oras.com/AR/2790N-33; Catalog Drawing URL: http://static.oras.com/catdrw/2790N-33; Dimension Drawing URL: http://static.oras.com/dimdrw/2790N-33; FDV Document URL: http://www.oras.com/datasheet/2790N-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2790N-33; Group: Shower set; Installation and Maintenance Guide URL: http://static.oras.com/manual/2790N-33; Interactive AR View URL: https://static.oras.com/AR/2790N-33; Manufacturer: Oras; Market: Denmark;Estonia;Finland;International;Lithuania;Latvia;Norway;Poland;Sweden;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2790N-33; Model: 2790N-33 Shower set; Name_en: 2790N-33 Shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2790N-33; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/2790N-33; Product URL: http://static.oras.com/2790N-33; Technical DataSheet URL: http://www.oras.com/datasheet/2790N-33/en; Type Name: 2790N-33 Shower set; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Hose guide, revolving; Flow Rate At 300kPa With Flow Reducers: 0.00882867 m3/s; Hand Shower Size: Ø110; Installation Type: Wall mounted; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Soap dish;Shower hose (1750 mm);Variable fixing points;Anti limescale technology (easy to clean);Twist guard for shower hose; Shower Spray: Normal;Massage;Rain; Shower Spray Number: 3 shower sprays; Surface treatment: Matt black; Working Pressure: 50 - 500 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2790N-33(2023); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 2790N-33; Name: 2790N-33 Shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.305266 m2; Volume: 0.022459 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2790N-33(2023): 2790N-33 Shower set; Family and Type: 2790N-33(2023): 2790N-33 Shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2790N-33(2023): 2790N-33 Shower set; Type Id: 2790N-33(2023): 2790N-33 Shower set; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
